# Keil uVision project bootloader.uvprojx, settings and files
target T100-Bootloader (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app\inc;..\bsp\inc;..\lib\inc;..\core
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../app/src/: main.c fs_api.c iap.c
  group BSP
    ../bsp/src/: delay.c spi_flash_bsp.c sys.c uart.c stmflash.c
  group LIB
    ../lib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_iwdg.c
  group CORE
    ../core/: core_cm3.c startup_stm32f10x_hd.s
