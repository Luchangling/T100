# Keil uVision project T100.uvprojx, settings and files
target T100 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: T100 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app\bms;..\app;..\app\daemon;..\app\file;..\app\fifo;..\app\gps;..\app\math;..\app\network;..\app\protocol;..\app\sensor;..\app\update;..\bsp;..\bsp\delay;..\bsp\flash;..\bsp\sys;..\bsp\timer;..\bsp\uart;..\core;..\lib\inc;..\lib;..\os;..\os\config;..\os\core;..\os\port;..\app\led;..\app\log
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../app/: main.c utility.c
    ../app/bms/: bms_service_bsp.c
    ../app/fifo/: fifo.c
    ../app/file/: config_service.c fs_api.c spi_flash_bsp.c stmflash.c system_state.c
    ../app/gps/: agps_service.c circular_queue.c gps.c gps_save.c gps_service.c nmea_protocol.c
    ../app/math/: applied_math.c
    ../app/network/: at_command.c gprs.c net_task.c socket.c
    ../app/protocol/: command.c protocol.c protocol_jt808.c
    ../app/sensor/: i2c_driver.c sensor_service.c
    ../app/update/: update_file.c update_service.c
    ../app/led/: led_service.c
    ../app/log/: log_service.c json.c
  group BSP
    ../bsp/: bsp.c
    ../bsp/delay/: delay.c
    ../bsp/sys/: malloc.c sys.c
    ../bsp/timer/: timer.c
    ../bsp/uart/: bms_service.c usart.c
  group LIB
    ../lib/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
  group OS
    ../os/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../os/port/: os_cpu_c.c os_cpu_a.asm
  group CORE
    ../core/: core_cm3.c startup_stm32f10x_hd.s
