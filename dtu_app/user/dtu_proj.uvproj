# Keil uVision project dtu_proj.uvproj, settings and files
target dtu (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dtu_proj +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app\bms;..\app;..\app\daemon;..\app\file;..\app\fifo;..\app\gps;..\app\math;..\app\network;..\app\protocol;..\app\sensor;..\app\update;..\bsp;..\bsp\delay;..\bsp\flash;..\bsp\sys;..\bsp\timer;..\bsp\uart;..\core;..\lib\inc;..\lib;..\os;..\os\config;..\os\core;..\os\port
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group bsp
    ../bsp/delay/: delay.c
    ../bsp/sys/: malloc.c sys.c
    ../bsp/timer/: timer.c
    ../bsp/uart/: usart.c
    ../bsp/: bsp.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group app
    ../app/: main.c utility.c
    ../app/daemon/: daemon_task.c
    ../app/fifo/: fifo.c
    ../app/file/: config_service.c system_state.c fs_api.c spi_flash_bsp.c stmflash.c
    ../app/gps/: circular_queue.c gps.c gps_save.c gps_service.c nmea_protocol.c agps_service.c
    ../app/math/: applied_math.c
    ../app/network/: at_command.c gprs.c net_task.c socket.c
    ../app/protocol/: protocol.c protocol_jt808.c command.c
    ../app/sensor/: i2c_driver.c MPU6050.c sensor_service.c
    ../app/bms/: bms_service_bsp.c
    ../bsp/uart/: bms_service.c
  group os
    ../os/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../os/port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
